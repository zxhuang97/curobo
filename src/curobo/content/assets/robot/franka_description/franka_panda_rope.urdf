Commit message: update urdf

File: src/curobo/content/assets/robot/franka_description/franka_panda_rope.urdf (robot description, URDF)
Before this commit: robot panda, 15 links, 14 joints
Joints:
- joint ee_fixed_joint: origin xyz=0.0 0. 0.11 rpy=0 0.0 0 -> xyz=0.0 0. 0.115 rpy=0 0.0 0
